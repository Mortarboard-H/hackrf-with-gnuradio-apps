options:
  parameters:
    generate_options: qt_gui
    id: test_jamming_TDMSingle
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: jammingSource_TDMSingle_0
  id: jammingSource_TDMSingle
  parameters:
    freq: 1000,2000,3000
    period: '1e-2'
    samp_rate: samp_rate
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 1.57542e9
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: Frequencies
    type: string
    value: 1000,4000
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [jammingSource_TDMSingle_0, '0', osmosdr_sink_0, '0']
- [jammingSource_TDMSingle_0, '0', qtgui_freq_sink_x_0, '0']
- [jammingSource_TDMSingle_0, '0', qtgui_time_sink_x_0, '0']
- [qtgui_edit_box_msg_0, msg, blocks_message_debug_0, print]
- [qtgui_edit_box_msg_0, msg, jammingSource_TDMSingle_0, cmd]

metadata:
  file_format: 1
