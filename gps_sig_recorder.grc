options:
  parameters:
    generate_options: qt_gui
    id: gps_sig_recorder
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BB_VGA
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '60'
    value: '38'
  states: {}
- name: IF_LNA
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: '40'
  states: {}
- name: amplifier
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: target_center-10e6
    step: '1'
    stop: target_center+10e6
    value: target_center
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: target_center
  id: variable
  parameters:
    value: 1.57542e9
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: E:\raw_data_hackrf\gps_2022_09_09.dat
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0,bias=1
    bb_gain0: BB_VGA
    bw0: 4.75e6
    freq0: center_freq
    gain0: amplifier
    gain_mode0: 'False'
    if_gain0: IF_LNA
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
