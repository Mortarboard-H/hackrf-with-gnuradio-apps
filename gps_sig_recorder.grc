options:
  parameters:
    generate_options: qt_gui
    id: gps_sig_recorder
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BB_VGA
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '60'
    value: '38'
  states: {}
- name: IF_LNA
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: '40'
  states: {}
- name: amplifier
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: target_center-10e6
    step: '1'
    stop: target_center+10e6
    value: target_center
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: target_center
  id: variable
  parameters:
    value: 1.57542e9
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: E:\raw_data_hackrf\gps_2022_09_19.dat
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: amplifier
    bandwidth: 2.75e6
    center_freq: center_freq
    dev_args: bias_tx=1,hackrf=1
    gain: IF_LNA
    samp_rate: samp_rate
    type: fc32
    vga: BB_VGA
  states: {}

connections:
- [soapy_hackrf_source_0, '0', blocks_file_sink_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
